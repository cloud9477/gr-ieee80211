options:
  parameters:
    generate_options: no_gui
    id: ap2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 5420e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: txp
  id: variable
  parameters:
    value: '0.98'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/cloud/sdr/cmu-mupkt_2x2_0.bin
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/cloud/sdr/cmu-mupkt_2x2_1.bin
    repeat: 'False'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    bw0: 20e6
    bw1: 20e6
    center_freq0: freq
    center_freq1: freq
    gain0: txp
    gain1: txp
    gain_type0: normalized
    gain_type1: normalized
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']
- [blocks_file_source_0_0, '0', uhd_usrp_sink_0, '1']

metadata:
  file_format: 1
