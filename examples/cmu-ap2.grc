options:
  parameters:
    generate_options: no_gui
    id: ap2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 5030e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: txp
  id: variable
  parameters:
    value: '0.4'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/cloud/sdr/gr-ieee80211/tools/sig80211MuNdp0.bin
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/cloud/sdr/gr-ieee80211/tools/sig80211MuNdp1.bin
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.2'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.2'
    type: complex
  states: {state: disabled}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.01
    mtu: '1500'
    port: '9528'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {state: disabled}
- name: ieee80211_encode_0
  id: ieee80211_encode
  parameters:
    tag: packet_len
  states: {state: disabled}
- name: ieee80211_modulation_0
  id: ieee80211_modulation
  parameters: {}
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    bw0: 20e6
    bw1: 20e6
    center_freq0: freq
    center_freq1: freq
    gain0: txp
    gain1: txp
    gain_type0: normalized
    gain_type1: normalized
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']
- [blocks_file_source_0_0, '0', uhd_usrp_sink_0, '1']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', uhd_usrp_sink_0, '1']
- [blocks_socket_pdu_0, pdus, ieee80211_encode_0, pdus]
- [ieee80211_encode_0, '0', ieee80211_modulation_0, '0']
- [ieee80211_encode_0, '1', ieee80211_modulation_0, '1']
- [ieee80211_modulation_0, '0', blocks_multiply_const_vxx_0, '0']
- [ieee80211_modulation_0, '1', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
