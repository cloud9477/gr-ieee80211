options:
  parameters:
    generate_options: no_gui
    id: sta1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 5420e6
  states: {}
- name: rxp
  id: variable
  parameters:
    value: '0.7'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/cloud/sdr/cmu-mupkt_2x2_1.bin
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '48'
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: '64'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: ieee80211_decode_0
  id: ieee80211_decode
  parameters: {}
  states: {}
- name: ieee80211_demod_0
  id: ieee80211_demod
  parameters:
    mugid: '2'
    mupos: '1'
    nrx: '1'
  states: {}
- name: ieee80211_signal_0
  id: ieee80211_signal
  parameters:
    nss: '1'
  states: {}
- name: ieee80211_sync_0
  id: ieee80211_sync
  parameters: {}
  states: {}
- name: ieee80211_trigger_0
  id: ieee80211_trigger
  parameters: {}
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1400'
    port: '9527'
    send_eof: 'False'
    type: byte
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 20e6
    center_freq0: freq
    gain0: rxp
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', ieee80211_signal_0, '3']
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_delay_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_divide_xx_0, '0', ieee80211_trigger_0, '0']
- [blocks_file_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_file_source_0, '0', blocks_delay_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_file_source_0, '0', ieee80211_signal_0, '2']
- [blocks_file_source_0, '0', ieee80211_sync_0, '1']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_0, '0', ieee80211_sync_0, '2']
- [blocks_moving_average_xx_1, '0', blocks_divide_xx_0, '1']
- [blocks_multiply_conjugate_cc_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', network_udp_sink_0, '0']
- [ieee80211_decode_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [ieee80211_demod_0, '0', ieee80211_decode_0, '0']
- [ieee80211_signal_0, '0', ieee80211_demod_0, '1']
- [ieee80211_signal_0, '1', ieee80211_demod_0, '2']
- [ieee80211_sync_0, '0', ieee80211_demod_0, '0']
- [ieee80211_sync_0, '0', ieee80211_signal_0, '0']
- [ieee80211_sync_0, '1', ieee80211_signal_0, '1']
- [ieee80211_trigger_0, '0', ieee80211_sync_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, '0', blocks_delay_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [uhd_usrp_source_0, '0', ieee80211_signal_0, '2']
- [uhd_usrp_source_0, '0', ieee80211_sync_0, '1']

metadata:
  file_format: 1
