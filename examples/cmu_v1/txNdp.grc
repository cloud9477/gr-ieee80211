options:
  parameters:
    generate_options: qt_gui
    id: cmuv1ndp
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq_100
  id: variable
  parameters:
    value: 5500e6
  states: {}
- name: freq_112
  id: variable
  parameters:
    value: 5560e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ../tmp/sig80211GenVhtNdp_2x2_0.bin
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: ../tmp/sig80211GenVhtNdp_2x2_1.bin
    repeat: 'False'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    bw0: 20e6
    bw1: 20e6
    center_freq0: freq_112
    center_freq1: freq_112
    gain0: '0.8'
    gain1: '0.8'
    gain_type0: normalized
    gain_type1: normalized
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']
- [blocks_file_source_1, '0', uhd_usrp_sink_0, '1']

metadata:
  file_format: 1
