options:
  parameters:
    generate_options: no_gui
    id: cmuv3ap
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq_100
  id: variable
  parameters:
    value: 5500e6
  states: {}
- name: freq_112
  id: variable
  parameters:
    value: 5600e6
  states: {}
- name: freq_132
  id: variable
  parameters:
    value: 5660e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    minoutbuf: 4096 * 512
    num_items: '64'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    minoutbuf: 4096 * 512
    num_items: '64'
    type: complex
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: '16'
    input_size: '64'
    minoutbuf: 4096 * 512
    tagname: '"packet_len"'
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_0_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: '16'
    input_size: '64'
    minoutbuf: 4096 * 512
    tagname: '"packet_len"'
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'False'
    minoutbuf: 4096 * 512
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'False'
    minoutbuf: 4096 * 512
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: ieee80211_decode_0
  id: ieee80211_decode
  parameters:
    ifdebug: 'True'
  states: {}
- name: ieee80211_demod2_0
  id: ieee80211_demod2
  parameters: {}
  states: {}
- name: ieee80211_encode2_0
  id: ieee80211_encode2
  parameters:
    minoutbuf: 4096 * 512
  states: {}
- name: ieee80211_modulation2_0
  id: ieee80211_modulation2
  parameters:
    minoutbuf: 4096 * 512
  states: {}
- name: ieee80211_pad2_0
  id: ieee80211_pad2
  parameters:
    minoutbuf: 4096 * 512
  states: {}
- name: ieee80211_pktgen_0
  id: ieee80211_pktgen
  parameters:
    minoutbuf: 4096 * 512
    tag: notag
  states: {}
- name: ieee80211_signal2_0
  id: ieee80211_signal2
  parameters: {}
  states: {}
- name: ieee80211_sync_0
  id: ieee80211_sync
  parameters: {}
  states: {}
- name: ieee80211_trigger_0
  id: ieee80211_trigger
  parameters: {}
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '65535'
    port: '9527'
    type: UDP_CLIENT
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '65535'
    port: '9528'
    type: UDP_SERVER
  states: {}
- name: presiso_0
  id: presiso
  parameters: {}
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    bw0: 20e6
    bw1: 20e6
    center_freq0: freq_112
    center_freq1: freq_112
    comment: Sync and TSB Tag
    gain0: '0.85'
    gain1: '0.85'
    gain_type0: normalized
    gain_type1: normalized
    len_tag_name: '"len"'
    nchan: '2'
    samp_rate: samp_rate
    sync: pc_clock_next_pps
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    bw0: 20e6
    bw1: 20e6
    center_freq0: freq_112
    center_freq1: freq_112
    gain0: '0.85'
    gain1: '0.85'
    gain_type0: normalized
    gain_type1: normalized
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0_0, '0']
- [digital_ofdm_cyclic_prefixer_0_0, '0', ieee80211_pad2_0, '0']
- [digital_ofdm_cyclic_prefixer_0_0_0, '0', ieee80211_pad2_0, '1']
- [fft_vxx_0_0, '0', digital_ofdm_cyclic_prefixer_0_0, '0']
- [fft_vxx_0_0_0, '0', digital_ofdm_cyclic_prefixer_0_0_0, '0']
- [ieee80211_decode_0, out, network_socket_pdu_0, pdus]
- [ieee80211_demod2_0, '0', ieee80211_decode_0, '0']
- [ieee80211_encode2_0, '0', ieee80211_modulation2_0, '0']
- [ieee80211_encode2_0, '1', ieee80211_modulation2_0, '1']
- [ieee80211_modulation2_0, '0', blocks_stream_to_vector_0, '0']
- [ieee80211_modulation2_0, '1', blocks_stream_to_vector_0_0, '0']
- [ieee80211_pad2_0, '0', uhd_usrp_sink_0_0, '0']
- [ieee80211_pad2_0, '1', uhd_usrp_sink_0_0, '1']
- [ieee80211_pktgen_0, '0', ieee80211_encode2_0, '0']
- [ieee80211_signal2_0, '0', ieee80211_demod2_0, '0']
- [ieee80211_signal2_0, '1', ieee80211_demod2_0, '1']
- [ieee80211_sync_0, '0', ieee80211_signal2_0, '0']
- [ieee80211_trigger_0, '0', ieee80211_sync_0, '0']
- [network_socket_pdu_0_0, pdus, ieee80211_modulation2_0, pdus]
- [network_socket_pdu_0_0, pdus, ieee80211_pktgen_0, pdus]
- [presiso_0, '0', ieee80211_trigger_0, '0']
- [presiso_0, '1', ieee80211_sync_0, '1']
- [uhd_usrp_source_0, '0', ieee80211_signal2_0, '1']
- [uhd_usrp_source_0, '0', ieee80211_sync_0, '2']
- [uhd_usrp_source_0, '0', presiso_0, '0']
- [uhd_usrp_source_0, '1', ieee80211_signal2_0, '2']

metadata:
  file_format: 1
