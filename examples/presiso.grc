options:
  parameters:
    category: '[IEEE 802.11 GR-WiFi]'
    generate_options: hb
    id: presiso
    output_language: python
    title: Pre Proc
  states: {}

blocks:
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    minoutbuf: 4096 * 512
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    minoutbuf: 4096 * 512
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: The first 16 samples are 0
    delay: '16'
    minoutbuf: 4096 * 512
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    minoutbuf: 4096 * 512
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '48'
    max_iter: '4000'
    minoutbuf: 4096 * 512
    scale: '1'
    type: complex
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: '64'
    max_iter: '4000'
    minoutbuf: 4096 * 512
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    minoutbuf: 4096 * 512
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: preac
    type: float
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: preconj
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: prein
    type: complex
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_delay_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_divide_xx_0, '0', pad_sink_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_0, '0', pad_sink_2, '0']
- [blocks_moving_average_xx_1, '0', blocks_divide_xx_0, '1']
- [blocks_multiply_conjugate_cc_0, '0', blocks_moving_average_xx_0, '0']
- [pad_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [pad_source_0, '0', blocks_delay_0, '0']
- [pad_source_0, '0', blocks_multiply_conjugate_cc_0, '1']

metadata:
  file_format: 1
