options:
  parameters:
    generate_options: no_gui
    id: wifirx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 2412e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1.5'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '9527'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/cloud/sdr/sig80211VhtGenCfoMcs100_1x1_0.bin
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_fading_model_0
  id: channels_fading_model
  parameters:
    LOS: 'False'
    N: '8'
    fDTs: 10.0/samp_rate
    seed: '0'
  states: {}
- name: channels_selective_fading_model2_0
  id: channels_selective_fading_model2
  parameters:
    LOS: 'False'
    N: '8'
    delay_maxdev: (0.5,0.7,0.9)
    delay_std: (1e-4,1e-4,1e-4)
    delays: (1.0,1.9,2.7)
    fDTs: 0.2/samp_rate
    mags: (1,0.95,0.8)
    ntaps: '8'
    seed: '0'
  states: {state: disabled}
- name: channels_selective_fading_model_0
  id: channels_selective_fading_model
  parameters:
    LOS: 'False'
    N: '8'
    delays: (0.0,0.1,1.3)
    fDTs: 10.0/samp_rate
    mags: (1,0.99,0.97)
    ntaps: '8'
    seed: '0'
  states: {state: disabled}
- name: ieee80211_decode_0
  id: ieee80211_decode
  parameters:
    inpara: '0'
  states: {}
- name: ieee80211_demod_0
  id: ieee80211_demod
  parameters:
    mugid: '2'
    mupos: '0'
  states: {}
- name: ieee80211_signal_0
  id: ieee80211_signal
  parameters: {}
  states: {}
- name: ieee80211_sync_0
  id: ieee80211_sync
  parameters: {}
  states: {}
- name: ieee80211_trigger_0
  id: ieee80211_trigger
  parameters: {}
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1400'
    port: '9527'
    send_eof: 'False'
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: presiso_0
  id: presiso
  parameters: {}
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: x(t)
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: x(t)
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', channels_fading_model_0, '0']
- [blocks_add_xx_0, '0', channels_selective_fading_model2_0, '0']
- [blocks_add_xx_0, '0', channels_selective_fading_model_0, '0']
- [blocks_file_source_0, '0', blocks_add_xx_0, '1']
- [blocks_throttle_0_0, '0', virtual_sink_0, '0']
- [channels_fading_model_0, '0', blocks_throttle_0_0, '0']
- [channels_selective_fading_model2_0, '0', blocks_throttle_0_0, '0']
- [channels_selective_fading_model_0, '0', blocks_throttle_0_0, '0']
- [ieee80211_decode_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [ieee80211_demod_0, '0', ieee80211_decode_0, '0']
- [ieee80211_signal_0, '0', ieee80211_demod_0, '0']
- [ieee80211_sync_0, '0', ieee80211_signal_0, '0']
- [ieee80211_trigger_0, '0', ieee80211_sync_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', network_udp_sink_0, '0']
- [presiso_0, '0', ieee80211_trigger_0, '0']
- [presiso_0, '1', ieee80211_sync_0, '1']
- [virtual_source_0, '0', ieee80211_signal_0, '1']
- [virtual_source_0, '0', ieee80211_sync_0, '2']
- [virtual_source_0, '0', presiso_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
