options:
  parameters:
    generate_options: no_gui
    id: wifirx2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq_100
  id: variable
  parameters:
    value: 5500e6
  states: {}
- name: freq_112
  id: variable
  parameters:
    value: 5560e6
  states: {}
- name: freq_132
  id: variable
  parameters:
    value: 5660e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ../tmp/sig80211GenMultipleMimo_2x2_0.bin
    minoutbuf: '1048576'
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: ../tmp/sig80211GenMultipleMimo_2x2_1.bin
    minoutbuf: '1048576'
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    minoutbuf: '1048576'
    num_items: '64'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    minoutbuf: '1048576'
    num_items: '64'
    type: complex
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    minoutbuf: '1048576'
    nthreads: '2'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    minoutbuf: '1048576'
    nthreads: '2'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: ieee80211_decode_0
  id: ieee80211_decode
  parameters:
    ifdebug: 'True'
    minoutbuf: '1048576'
  states: {}
- name: ieee80211_demod2_0
  id: ieee80211_demod2
  parameters:
    minoutbuf: '1048576'
  states: {}
- name: ieee80211_equalizer2_0
  id: ieee80211_equalizer2
  parameters:
    minoutbuf: '1048576'
  states: {}
- name: ieee80211_signal2_0
  id: ieee80211_signal2
  parameters:
    minoutbuf: '1048576'
  states: {}
- name: ieee80211_sync_0
  id: ieee80211_sync
  parameters:
    minoutbuf: '1048576'
  states: {}
- name: ieee80211_trigger_0
  id: ieee80211_trigger
  parameters:
    minoutbuf: '1048576'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '65535'
    port: '9527'
    type: UDP_CLIENT
  states: {}
- name: presiso_0
  id: presiso
  parameters: {}
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    bw0: 20e6
    bw1: 20e6
    center_freq0: freq_112
    center_freq1: freq_112
    gain0: '0.8'
    gain1: '0.8'
    gain_type0: normalized
    gain_type1: normalized
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', ieee80211_signal2_0, '1']
- [blocks_file_source_0, '0', ieee80211_sync_0, '2']
- [blocks_file_source_0, '0', presiso_0, '0']
- [blocks_file_source_0_0, '0', ieee80211_signal2_0, '2']
- [blocks_stream_to_vector_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0_0, '0']
- [fft_vxx_0_0, '0', ieee80211_equalizer2_0, '0']
- [fft_vxx_0_0_0, '0', ieee80211_equalizer2_0, '1']
- [ieee80211_decode_0, out, network_socket_pdu_0, pdus]
- [ieee80211_demod2_0, '0', blocks_stream_to_vector_0, '0']
- [ieee80211_demod2_0, '1', blocks_stream_to_vector_0_0, '0']
- [ieee80211_equalizer2_0, '0', ieee80211_decode_0, '0']
- [ieee80211_signal2_0, '0', ieee80211_demod2_0, '0']
- [ieee80211_signal2_0, '1', ieee80211_demod2_0, '1']
- [ieee80211_sync_0, '0', ieee80211_signal2_0, '0']
- [ieee80211_trigger_0, '0', ieee80211_sync_0, '0']
- [presiso_0, '0', ieee80211_trigger_0, '0']
- [presiso_0, '1', ieee80211_sync_0, '1']
- [uhd_usrp_source_0, '0', ieee80211_signal2_0, '1']
- [uhd_usrp_source_0, '0', ieee80211_sync_0, '2']
- [uhd_usrp_source_0, '0', presiso_0, '0']
- [uhd_usrp_source_0, '1', ieee80211_signal2_0, '2']

metadata:
  file_format: 1
