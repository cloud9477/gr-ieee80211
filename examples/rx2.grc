options:
  parameters:
    generate_options: no_gui
    id: wifirx2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq_100
  id: variable
  parameters:
    value: 5500e6
  states: {}
- name: freq_132
  id: variable
  parameters:
    value: 5660e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/cloud/sdr/sig80211GenMultipleMimo_2x2_0.bin
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/cloud/sdr/sig80211GenMultipleMimo_2x2_1.bin
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: ieee80211_decode_0
  id: ieee80211_decode
  parameters:
    inpara: '1'
  states: {}
- name: ieee80211_demod2_0
  id: ieee80211_demod2
  parameters:
    mugid: '2'
    mupos: '0'
  states: {}
- name: ieee80211_signal2_0
  id: ieee80211_signal2
  parameters: {}
  states: {}
- name: ieee80211_sync_0
  id: ieee80211_sync
  parameters: {}
  states: {}
- name: ieee80211_trigger_0
  id: ieee80211_trigger
  parameters: {}
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1400'
    port: '9527'
    send_eof: 'False'
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: presiso_0
  id: presiso
  parameters: {}
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    bw0: 20e6
    bw1: 20e6
    center_freq0: freq_132
    center_freq1: freq_132
    gain0: '0.8'
    gain1: '0.8'
    gain_type0: normalized
    gain_type1: normalized
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_throttle_0, '0', ieee80211_signal2_0, '1']
- [blocks_throttle_0, '0', ieee80211_sync_0, '2']
- [blocks_throttle_0, '0', presiso_0, '0']
- [blocks_throttle_0_0, '0', ieee80211_signal2_0, '2']
- [ieee80211_decode_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [ieee80211_demod2_0, '0', ieee80211_decode_0, '0']
- [ieee80211_signal2_0, '0', ieee80211_demod2_0, '0']
- [ieee80211_signal2_0, '1', ieee80211_demod2_0, '1']
- [ieee80211_sync_0, '0', ieee80211_signal2_0, '0']
- [ieee80211_trigger_0, '0', ieee80211_sync_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', network_udp_sink_0, '0']
- [presiso_0, '0', ieee80211_trigger_0, '0']
- [presiso_0, '1', ieee80211_sync_0, '1']
- [uhd_usrp_source_0, '0', ieee80211_signal2_0, '1']
- [uhd_usrp_source_0, '0', ieee80211_sync_0, '2']
- [uhd_usrp_source_0, '0', presiso_0, '0']
- [uhd_usrp_source_0, '1', ieee80211_signal2_0, '2']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
