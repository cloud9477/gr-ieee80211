options:
  parameters:
    generate_options: no_gui
    id: wifitx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq_100
  id: variable
  parameters:
    value: 5500e6
  states: {}
- name: freq_112
  id: variable
  parameters:
    value: 5560e6
  states: {}
- name: freq_132
  id: variable
  parameters:
    value: 5660e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ../tmp/sig80211GenGr0.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: ../tmp/sig80211GenGr1.bin
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: ieee80211_encode_0
  id: ieee80211_encode
  parameters:
    tag: packet_len
  states: {}
- name: ieee80211_modulation_0
  id: ieee80211_modulation
  parameters: {}
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '65535'
    port: '9528'
    type: UDP_SERVER
  states: {}
- name: note_0
  id: note
  parameters:
    note: '!!!USRP TSB Tag: len'
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: '!!!USRP Sync: Clock on Next PPS'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 20e6
    center_freq0: freq_112
    comment: Sync and TSB Tag
    gain0: '0.8'
    gain_type0: normalized
    len_tag_name: '"len"'
    samp_rate: samp_rate
    sync: pc_clock_next_pps
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    bw0: 20e6
    bw1: 20e6
    center_freq0: freq_112
    center_freq1: freq_132
    comment: Sync and TSB Tag
    gain0: '0.8'
    gain1: '0.8'
    gain_type0: normalized
    gain_type1: normalized
    len_tag_name: '"len"'
    nchan: '2'
    samp_rate: samp_rate
    sync: pc_clock_next_pps
    type: fc32
  states: {state: disabled}

connections:
- [ieee80211_encode_0, '0', ieee80211_modulation_0, '0']
- [ieee80211_encode_0, '1', ieee80211_modulation_0, '1']
- [ieee80211_modulation_0, '0', blocks_file_sink_0, '0']
- [ieee80211_modulation_0, '0', uhd_usrp_sink_0, '0']
- [ieee80211_modulation_0, '0', uhd_usrp_sink_0_0, '0']
- [ieee80211_modulation_0, '1', blocks_file_sink_0_0, '0']
- [ieee80211_modulation_0, '1', blocks_null_sink_0, '0']
- [ieee80211_modulation_0, '1', uhd_usrp_sink_0_0, '1']
- [network_socket_pdu_0, pdus, ieee80211_encode_0, pdus]

metadata:
  file_format: 1
