options:
  parameters:
    generate_options: qt_gui
    id: wifitx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '5000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: ieee80211_encode_0
  id: ieee80211_encode
  parameters:
    tag: packet_len
  states: {}

connections:
- [blocks_message_strobe_0, strobe, ieee80211_encode_0, pdus]
- [ieee80211_encode_0, '0', blocks_null_sink_0, '0']
- [ieee80211_encode_0, '1', blocks_null_sink_0_0, '0']

metadata:
  file_format: 1
