options:
  parameters:
    generate_options: qt_gui
    id: wifitx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/cloud/sdr/sig80211Gr0.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/cloud/sdr/sig80211Gr1.bin
    type: complex
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '2000'
  states: {}
- name: ieee80211_encode_0
  id: ieee80211_encode
  parameters:
    tag: packet_len
  states: {}
- name: ieee80211_modulation_0
  id: ieee80211_modulation
  parameters: {}
  states: {}

connections:
- [blocks_message_strobe_0, strobe, ieee80211_encode_0, pdus]
- [ieee80211_encode_0, '0', ieee80211_modulation_0, '0']
- [ieee80211_encode_0, '1', ieee80211_modulation_0, '1']
- [ieee80211_modulation_0, '0', blocks_file_sink_0, '0']
- [ieee80211_modulation_0, '1', blocks_file_sink_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
