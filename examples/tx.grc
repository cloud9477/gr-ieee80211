options:
  parameters:
    generate_options: no_gui
    id: wifitx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 5500e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/cloud/sdr/sig80211Gr0.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/cloud/sdr/sig80211Gr1.bin
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: ieee80211_encode_0
  id: ieee80211_encode
  parameters:
    tag: packet_len
  states: {}
- name: ieee80211_modulation_0
  id: ieee80211_modulation
  parameters: {}
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '65535'
    port: '9528'
    type: UDP_SERVER
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 20e6
    center_freq0: freq
    gain0: '0.8'
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    bw0: 20e6
    bw1: 20e6
    center_freq0: freq
    center_freq1: freq
    gain0: '0.9'
    gain1: '0.9'
    gain_type0: normalized
    gain_type1: normalized
    len_tag_name: '"packet_len"'
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [ieee80211_encode_0, '0', ieee80211_modulation_0, '0']
- [ieee80211_encode_0, '1', ieee80211_modulation_0, '1']
- [ieee80211_modulation_0, '0', blocks_file_sink_0, '0']
- [ieee80211_modulation_0, '0', uhd_usrp_sink_0, '0']
- [ieee80211_modulation_0, '0', uhd_usrp_sink_0_0, '0']
- [ieee80211_modulation_0, '1', blocks_file_sink_0_0, '0']
- [ieee80211_modulation_0, '1', blocks_null_sink_0, '0']
- [ieee80211_modulation_0, '1', uhd_usrp_sink_0_0, '1']
- [network_socket_pdu_0, pdus, ieee80211_encode_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.4.0
