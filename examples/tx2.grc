options:
  parameters:
    generate_options: qt_gui
    id: wifitx2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq_100
  id: variable
  parameters:
    value: 5500e6
  states: {}
- name: freq_112
  id: variable
  parameters:
    value: 5560e6
  states: {}
- name: freq_132
  id: variable
  parameters:
    value: 5660e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ../tmp/sig80211GenGr0.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: ../tmp/sig80211GenGr1.bin
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    minoutbuf: 4096 * 512
    num_items: '64'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    minoutbuf: 4096 * 512
    num_items: '64'
    type: complex
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: '16'
    input_size: '64'
    minoutbuf: 4096 * 512
    tagname: '"packet_len"'
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_0_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: '16'
    input_size: '64'
    minoutbuf: 4096 * 512
    tagname: '"packet_len"'
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'False'
    minoutbuf: 4096 * 512
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'False'
    minoutbuf: 4096 * 512
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: ieee80211_encode2_0
  id: ieee80211_encode2
  parameters:
    minoutbuf: 4096 * 512
  states: {}
- name: ieee80211_modulation2_0
  id: ieee80211_modulation2
  parameters:
    minoutbuf: 4096 * 512
  states: {}
- name: ieee80211_pad2_0
  id: ieee80211_pad2
  parameters:
    minoutbuf: 4096 * 512
  states: {}
- name: ieee80211_pktgen_0
  id: ieee80211_pktgen
  parameters:
    minoutbuf: 4096 * 512
    tag: notag
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '65535'
    port: '9528'
    type: UDP_SERVER
  states: {}
- name: note_0
  id: note
  parameters:
    note: '!!!USRP TSB Tag: len'
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: '!!!USRP Sync: Clock on Next PPS'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '4000'
    srate: samp_rate
    type: complex
    update_time: '0.01'
    ylabel: Amplitude1
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '4000'
    srate: samp_rate
    type: complex
    update_time: '0.01'
    ylabel: Amplitude0
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    bw0: 20e6
    bw1: 20e6
    center_freq0: freq_112
    center_freq1: freq_112
    comment: Sync and TSB Tag
    gain0: '0.8'
    gain1: '0.8'
    gain_type0: normalized
    gain_type1: normalized
    len_tag_name: '"len"'
    nchan: '2'
    samp_rate: samp_rate
    sync: pc_clock_next_pps
    type: fc32
  states: {state: disabled}

connections:
- [blocks_stream_to_vector_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0_0, '0']
- [digital_ofdm_cyclic_prefixer_0_0, '0', ieee80211_pad2_0, '0']
- [digital_ofdm_cyclic_prefixer_0_0_0, '0', ieee80211_pad2_0, '1']
- [fft_vxx_0_0, '0', digital_ofdm_cyclic_prefixer_0_0, '0']
- [fft_vxx_0_0_0, '0', digital_ofdm_cyclic_prefixer_0_0_0, '0']
- [ieee80211_encode2_0, '0', ieee80211_modulation2_0, '0']
- [ieee80211_encode2_0, '1', ieee80211_modulation2_0, '1']
- [ieee80211_modulation2_0, '0', blocks_stream_to_vector_0, '0']
- [ieee80211_modulation2_0, '1', blocks_stream_to_vector_0_0, '0']
- [ieee80211_pad2_0, '0', blocks_file_sink_0, '0']
- [ieee80211_pad2_0, '0', qtgui_time_sink_x_1, '0']
- [ieee80211_pad2_0, '0', uhd_usrp_sink_0_0, '0']
- [ieee80211_pad2_0, '1', blocks_file_sink_0_0, '0']
- [ieee80211_pad2_0, '1', qtgui_time_sink_x_0, '0']
- [ieee80211_pad2_0, '1', uhd_usrp_sink_0_0, '1']
- [ieee80211_pktgen_0, '0', ieee80211_encode2_0, '0']
- [network_socket_pdu_0, pdus, ieee80211_modulation2_0, pdus]
- [network_socket_pdu_0, pdus, ieee80211_pktgen_0, pdus]

metadata:
  file_format: 1
